# Keil uVision project usb_cdc.uvprojx, settings and files
target usb_cdc (ARM-ADS)
  device: STM32F207VGTx STMicroelectronics
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3") TZ
  output: usb_cdc +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F207xx
  c include: ../../Core/Inc;../../LWIP/App;../../LWIP/Target;../../USB_DEVICE/App;../../USB_DEVICE/Target;../../Middlewares/Third_Party/LwIP/src/include;../../Middlewares/Third_Party/LwIP/system;../../Drivers/STM32F2xx_HAL_Driver/Inc;../../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../../Middlewares/Third_Party/LwIP/src/include/lwip;../../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../../Middlewares/Third_Party/LwIP/src/include/netif;../../Middlewares/Third_Party/LwIP/src/include/posix;../../Middlewares/Third_Party/LwIP/src/include/posix/sys;../../Middlewares/Third_Party/LwIP/system/arch;../../Drivers/CMSIS/Include
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Application/User/Core
    ../../Core/Src/: main.c gpio.c crc.c usart.c stm32f2xx_it.c stm32f2xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../../USB_DEVICE/Target/: usbd_conf.c
  group Application/User/LWIP/Target
    ../../LWIP/Target/: ethernetif.c
  group Application/User/LWIP/App
    ../../LWIP/App/: lwip.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_ll_gpio.c stm32f2xx_hal_eth.c stm32f2xx_ll_rcc.c stm32f2xx_ll_utils.c stm32f2xx_ll_exti.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_pcd.c stm32f2xx_ll_usb.c stm32f2xx_ll_crc.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_ll_usart.c stm32f2xx_ll_dma.c
  group Drivers/CMSIS
    ../../Core/Src/: system_stm32f2xx.c
  group Middlewares/LwIP
    ../../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c slipif.c lowpan6.c
    ../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group Middlewares/USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
