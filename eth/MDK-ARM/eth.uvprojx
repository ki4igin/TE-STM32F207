# Keil uVision project eth.uvprojx, settings and files
target eth (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207VGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3") TZ
  output: eth +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F207xx
  c include: ..\code\Src;../code/Middlewares/Third_Party/LwIP/src/include;../code/Middlewares/Third_Party/LwIP/system;../code/Drivers/STM32F2xx_HAL_Driver/Inc;../code/Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../code/Middlewares/Third_Party/LwIP/src/include/netif/ppp;../code/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../code/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../code/Drivers/CMSIS/Device/ST/STM32F2xx/Include;../code/Middlewares/Third_Party/LwIP/src/include/lwip;../code/Middlewares/Third_Party/LwIP/src/include/lwip/apps;../code/Middlewares/Third_Party/LwIP/src/include/lwip/priv;../code/Middlewares/Third_Party/LwIP/src/include/lwip/prot;../code/Middlewares/Third_Party/LwIP/src/include/netif;../code/Middlewares/Third_Party/LwIP/src/include/posix;../code/Middlewares/Third_Party/LwIP/src/include/posix/sys;../code/Middlewares/Third_Party/LwIP/system/arch;../code/Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Application/User
    ../code/Src/: main.c gpio.c crc.c lwip.c ethernetif.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f2xx_it.c stm32f2xx_hal_msp.c debug.c
  group Drivers/STM32F2xx_HAL_Driver
    ../code/Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_ll_gpio.c stm32f2xx_hal_eth.c stm32f2xx_ll_rcc.c stm32f2xx_ll_utils.c stm32f2xx_ll_exti.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_pcd.c stm32f2xx_ll_usb.c stm32f2xx_ll_crc.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_ll_usart.c stm32f2xx_ll_dma.c
  group Drivers/CMSIS
    ../code/Src/: system_stm32f2xx.c
  group Middlewares/LwIP
    ../code/Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../code/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c slipif.c lowpan6.c
    ../code/Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../code/Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../code/Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../code/Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../code/Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group Middlewares/USB_Device_Library
    ../code/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../code/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
