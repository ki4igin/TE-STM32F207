# Keil uVision project fdas.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F207VGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: fdas
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.6.0
