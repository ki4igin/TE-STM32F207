# Keil uVision project eth_udp.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F207VGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: eth_udp
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=2
  c define: STM32F207xx,USE_FULL_LL_DRIVER,USE_HAL_DRIVER
  c include: ..\code\drivers\CMSIS\Include;..\code\LWIP\LwIP\src\include;..\code\periph;..\code\drivers\STM32F2xx_HAL_Driver\Inc;..\code\LWIP\App;..\code\LWIP\Target;..\code;..\code\drivers\CMSIS\Device\ST\STM32F2xx\Include;..\code\LWIP\LwIP\system
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: startup_stm32f207xx.s
    ../code/: main.c stm32f2xx_it.c udp_c.c
    ../code/periph/: gpio.c stm32f2xx_hal_msp.c system_stm32f2xx.c tim.c
    ../code/LWIP/App/: lwip.c
    ../code/LWIP/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../code/LWIP/LwIP/src/apps/mqtt/: mqtt.c
    ../code/LWIP/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../code/LWIP/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../code/LWIP/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../code/LWIP/LwIP/src/netif/: ethernet.c lowpan6.c slipif.c
    ../code/LWIP/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../code/drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_exti.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_ll_dma.c stm32f2xx_ll_exti.c stm32f2xx_ll_gpio.c stm32f2xx_ll_rcc.c stm32f2xx_ll_tim.c stm32f2xx_ll_utils.c
    ../code/LWIP/Target/: ethernetif.c
